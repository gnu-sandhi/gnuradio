<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>Transfer_function_Denominator</key>
<param><key>id</key><value>Transfer_function_Denominator_0</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>Transfer_function_Numerator</key>
<param><key>id</key><value>Transfer_function_Numerator_0</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0_3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0_3_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>Polezero_Plot</key>
<param><key>id</key><value>Polezero_Plot_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>order</key><value>1</value></param>
<param><key>itype</key><value>12</value></param>
</block>
<block>
<key>Max_val</key>
<param><key>id</key><value>Max_val_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>tstart</key><value>0</value></param>
<param><key>tstop</key><value>1</value></param>
<param><key>tstep</key><value>0.01</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Number Plot</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>36</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>3</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>36</value></param>
</block>
<block>
<key>plot_sink</key>
<param><key>id</key><value>plot_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>gsz</key><value>500</value></param>
<param><key>zoom</key><value>0</value></param>
</block>
<block>
<key>plot_sink</key>
<param><key>id</key><value>plot_sink_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>gsz</key><value>500</value></param>
<param><key>zoom</key><value>0</value></param>
</block>
<block>
<key>Comparator</key>
<param><key>id</key><value>Comparator_0</value></param>
<param><key>high_val</key><value>5</value></param>
<param><key>low_val</key><value>-5</value></param>
<param><key>ref_val</key><value>36</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0</value></param>
<param><key>file</key><value>test.grc</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>rel_rate</key><value>1</value></param>
<param><key>max_seg_size</key><value>1000000</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>detached</key><value>False</value></param>
</block>
<block>
<key>Transfer_function_Response</key>
<param><key>id</key><value>Transfer_function_Response_0</value></param>
<param><key>order</key><value>2</value></param>
<param><key>itype</key><value>12</value></param>
<param><key>tstart</key><value>0</value></param>
<param><key>tstop</key><value>500</value></param>
<param><key>tstep</key><value>1</value></param>
</block>
<connection><source_block_id>Transfer_function_Denominator_0</source_block_id><sink_block_id>Transfer_function_Response_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>Transfer_function_Numerator_0</source_block_id><sink_block_id>Transfer_function_Response_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Transfer_function_Numerator_0</source_block_id><sink_block_id>Polezero_Plot_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>const_source_x_0_3_0</source_block_id><sink_block_id>Transfer_function_Denominator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>const_source_x_0_0</source_block_id><sink_block_id>Transfer_function_Denominator_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>const_source_x_0_1</source_block_id><sink_block_id>Transfer_function_Denominator_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>const_source_x_0_3</source_block_id><sink_block_id>Transfer_function_Numerator_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>const_source_x_0_2</source_block_id><sink_block_id>Transfer_function_Numerator_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>const_source_x_0</source_block_id><sink_block_id>Transfer_function_Numerator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Transfer_function_Response_0</source_block_id><sink_block_id>Max_val_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Max_val_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Transfer_function_Response_0</source_block_id><sink_block_id>Comparator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Comparator_0</source_block_id><sink_block_id>plot_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Transfer_function_Response_0</source_block_id><sink_block_id>plot_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Transfer_function_Denominator_0</source_block_id><sink_block_id>Polezero_Plot_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>Transfer_function_Response_0</source_block_id><sink_block_id>blocks_file_meta_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
